# Keil uVision project finalProject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: finalProject
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: Blinky.c Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c LED.c LED.h IRQ.c KBD.c KBD.h system_LPC17xx.h audioMenu.c haas.c merc.c redbull.c adcuser.c adcuser.h audio.h type.h usb.h usbaudio.h usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h LPC17xx.h
  group Startup Files
    ./: core_cm3.c startup_LPC17xx.s system_LPC17xx.c
software components: CMSIS:CORE 5.4.0
